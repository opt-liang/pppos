# Keil uVision project pppos.uvprojx, settings and files
target pppos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: pppos
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ..\Src\LwIP\system\arch; ..\Src\LwIP\src\include\lwip\apps; ..\Src\LwIP\src\include\lwip\priv; ..\Src\LwIP\src\include\posix\sys; ..\Src\LwIP\src\include\posix; ..\Src\LwIP\src\include\netif; ..\Src\LwIP\src\include\netif\ppp; ..\Src\LwIP\src\include\posix; ..\Src\LwIP\src\include\posix\sys; ..\Src\LwIP\src\include; ..\Src\LwIP\system; ..\Src\Comm; ..\Src\Hw
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c freertos.c stm32f1xx_hal_msp.c lwip.c usart.c dma.c gpio.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c tasks.c timers.c queue.c event_groups.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c
  group lwip
    ../Src/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c sockets.c tcpip.c
    ../Src/LwIP/src/core/: def.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Src/LwIP/src/core/ipv4/: icmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Src/LwIP/src/netif/ppp/: fsm.c ipcp.c lcp.c magic.c ppp.c pppapi.c pppos.c utils.c vj.c auth.c
    ../Src/LwIP/system/OS/: sys_arch.c
  group uart
    ../Src/Hw/: uart_driver.c
  group comm
    ../Src/Comm/: cycle_queue.c common.c
  group pppapp
    ../Src/app/: pppapp.c
  group mqtt
    ../Src/LwIP/src/apps/mqtt/: mqtt.c
    ../Src/mqtt/: test_mqtt.c
software components: CMSIS:CORE 4.3.0
